/*
 * 广播窗口 —— 2026-10-14（build 90）。
 *
 * 为什么要有它：价签原来**24 小时常开广播**（间隔 100ms、duration=0 永不超时）。
 * 按射频占空比估：100ms 间隔 ≈0.1 mA ≈ **2.4 mAh/天** —— 而整屏刷新那笔
 * （0.067 mAh/次、一天一次）只有它的 1/35。也就是说：**只要价签不再需要
 * "随时能被找到"，射频就是省电里最大的一块**。
 *
 * 用户 2026-10-14 拍板："把广播改成窗口"（原话是问"你 0 点前后会把广播打开吗"）。
 * 于是：平时不广播，只在三个时段开窗：
 *   ① **上电/复位后先开一段长窗**（默认 5 分钟）—— 刷完机、换电池、想用手机连，
 *      都靠它；想手动连就按一下 RST，这个窗口就当"配对键"。
 *   ② **每天 0 点前后**（默认 23:50:00 起 **20 分钟** —— 故意放宽：这个窗口是按
 *      "价签自己认为的几点"算的，频源是内部 RC，几个月下来可能漂几分钟；
 *      窄了就会漂出窗口、永远接不到基站那轮跨天推送）—— 顺便每天对一次表。
 *   ③ **兜底窗口**（默认每 6 小时开 30 秒）—— 基站想临时推东西（换城市、改纪念日、
 *      新月休班表）不用干等到第二天 0 点。
 * 三档加起来一天只开 ≈21.5 分钟 = **1.5% 占空比**（≈0.036 mAh/天 vs 常开的 2.4）。
 *
 * ⚠ **这个文件里没有硬件**：纯 C、只看"跑了多久 + 现在几点"，所以主机端能编同一份
 *   自测（tools/test_adv_win.py）—— 尤其能直接算出"一天里开窗占多少比例"，
 *   这正是省电那笔账的分子。
 *
 * ⚠ 前提：**价签自己的钟得准**，否则它不知道该在什么时候开窗（0 点那个窗口）。
 *   这也是为什么这件事排在 build 89（时基修准）之后做。
 */
#ifndef __ZK_ADV_WIN_H__
#define __ZK_ADV_WIN_H__

#include <stdint.h>

typedef struct
{
    uint32_t boot_ms;        /* 上电后先开多久（毫秒；0 = 不要这个窗口） */
    uint32_t day_start_s;    /* 每天窗口的起点（本地一天里的秒，0..86399） */
    uint32_t day_len_s;      /* 每天窗口多长（秒；0 = 不要这个窗口） */
    uint32_t fb_every_s;     /* 兜底窗口：每隔多少秒开一次（0 = 不要） */
    uint32_t fb_len_s;       /* 兜底窗口多长（秒） */
} zk_adv_win_cfg_t;

/* 现在是不是落在"每天那一窗"里（本地墙上时间）？
   广播窗口用它、省电方案的"只在 0 点刷"也用它 —— **同一个定义**，免得两边说不到一块去。 */
static inline int zk_adv_win_in_day_window(uint32_t wall_s, const zk_adv_win_cfg_t *c)
{
    uint32_t off;

    if (0u == c->day_len_s)
    {
        return 0;
    }
    off = ((wall_s % 86400u) + 86400u - (c->day_start_s % 86400u)) % 86400u;
    return (off < c->day_len_s) ? 1 : 0;
}

/*
 * 现在该不该开广播？
 *   uptime_ms：开机以来多少毫秒（单调）
 *   wall_s   ：本地墙上时间（秒，= 基站/网页给的时间戳 + 时区 + 走时）；**跟对时无关**
 *   synced   ：时间同步过没有（0 = 从来没有，那就要一直开着等人来对表）
 * 返回 1 = 开，0 = 关。
 */
static inline int zk_adv_win_open(uint32_t uptime_ms, uint32_t wall_s, int synced,
                                  const zk_adv_win_cfg_t *c)
{
    uint32_t tod;
    uint32_t off;

    /* ① 上电/复位后的长窗口（刷机、换电池、想用手机连） */
    if ((0u != c->boot_ms) && (uptime_ms < c->boot_ms))
    {
        return 1;
    }

    /* ② 从来没同步过时间：一直开着 —— 不然基站/网页根本没机会把时间送进来 */
    if (!synced)
    {
        return 1;
    }

    tod = wall_s % 86400u;

    /* ③ 每天 0 点前后那一窗（**要跨午夜**：起点 23:59:30 属于"前一天"） */
    if (0u != c->day_len_s)
    {
        off = (tod + 86400u - (c->day_start_s % 86400u)) % 86400u;
        if (off < c->day_len_s)
        {
            return 1;
        }
    }

    /* ④ 兜底窗口：按"本地一天里的秒"取模 —— 也就是固定在 00:00/06:00/12:00/18:00
          （本地时间，可预期；0 点那一次跟上面那窗重叠，不额外多开） */
    if ((0u != c->fb_every_s) && (0u != c->fb_len_s))
    {
        if ((tod % c->fb_every_s) < c->fb_len_s)
        {
            return 1;
        }
    }

    return 0;
}

#endif /* __ZK_ADV_WIN_H__ */
