/*
 * 二十四节气 —— 见 jieqi.h。表从原厂 GUI/Lunar.c 生成，别手改。
 */
#include "jieqi.h"

/* 2000~2050 年，每年 3 个字节：24 个节气各 1 bit（1 = 基准日要修正） */
static const uint8_t s_year_bit[153] = {
    0x4E, 0xA6, 0x99, 0x9C, 0xA2, 0x98, 0x80, 0x00, 0x18, 0x00, 0x10, 0x24,
    0x4E, 0xA6, 0x99, 0x9C, 0xA2, 0x98, 0x80, 0x82, 0x18, 0x00, 0x10, 0x24,
    0x4E, 0xA6, 0xD9, 0x9E, 0xA2, 0x98, 0x80, 0x82, 0x18, 0x00, 0x10, 0x04,
    0x4E, 0xE6, 0xD9, 0x9E, 0xA6, 0xA8, 0x80, 0x82, 0x18, 0x00, 0x10, 0x00,
    0x0F, 0xE6, 0xD9, 0xBE, 0xA6, 0x98, 0x88, 0x82, 0x18, 0x80, 0x00, 0x00,
    0x0F, 0xEF, 0xD9, 0xBE, 0xA6, 0x99, 0x8C, 0x82, 0x98, 0x80, 0x00, 0x00,
    0x0F, 0xEF, 0xDB, 0xBE, 0xA6, 0x99, 0x9C, 0xA2, 0x98, 0x80, 0x00, 0x18,
    0x0F, 0xEF, 0xDB, 0xBE, 0xA6, 0x99, 0x9C, 0xA2, 0x98, 0x80, 0x00, 0x18,
    0x0F, 0xEF, 0xDB, 0xBE, 0xA2, 0x99, 0x8C, 0xA0, 0x98, 0x80, 0x82, 0x18,
    0x0B, 0xEF, 0xDB, 0xBE, 0xA6, 0x99, 0x8C, 0xA2, 0x98, 0x80, 0x82, 0x18,
    0x0F, 0xEF, 0xDB, 0xBE, 0xE6, 0xD9, 0x9E, 0xA2, 0x98, 0x80, 0x82, 0x18,
    0x0F, 0xEF, 0xFB, 0xBF, 0xE6, 0xD9, 0x9E, 0xA6, 0x98, 0x80, 0x82, 0x18,
    0x0F, 0xFF, 0xFF, 0xFC, 0xEF, 0xD9, 0xBE, 0xA6, 0x18,
};

/* 每个月两个节气的基准日（上半月、下半月） */
static const uint8_t s_day_base[24] = {
    6, 20, 4, 19, 6, 21,
    5, 20, 6, 21, 6, 21,
    7, 23, 8, 23, 8, 23,
    8, 24, 8, 22, 7, 22,
};

const char *const zk_jieqi_name[24] = {
    "小寒",
    "大寒",
    "立春",
    "雨水",
    "惊蛰",
    "春分",
    "清明",
    "谷雨",
    "立夏",
    "小满",
    "芒种",
    "夏至",
    "小暑",
    "大暑",
    "立秋",
    "处暑",
    "白露",
    "秋分",
    "寒露",
    "霜降",
    "立冬",
    "小雪",
    "大雪",
    "冬至",
};

uint8_t zk_jieqi_date(uint16_t year, uint8_t mon, uint8_t day)
{
    uint8_t bak, value, jq, date;

    if (year < ZK_JIEQI_YEAR_MIN || year > ZK_JIEQI_YEAR_MAX)
    {
        return 0;
    }
    if (mon < 1 || mon > 12)
    {
        return 0;
    }

    jq = ZK_JIEQI_IDX(mon, day);
    bak = s_year_bit[(uint32_t)(year - ZK_JIEQI_YEAR_MIN) * 3u + (jq >> 3)];
    value = (uint8_t)((bak << (jq & 7)) & 0x80u);

    date = s_day_base[jq];
    if (value != 0)
    {
        /* 这四个节气在 2044 年之前是"加一天"，之后改成"减一天"
           （原厂代码里就是这么写的，照搬） */
        if ((jq == 1 || jq == 11 || jq == 18 || jq == 21) && year < 2044)
        {
            date++;
        }
        else
        {
            date--;
        }
    }
    return date;
}
